** SPICE netlist generated by bigspicy.py at Fri Dec  9 11:10:03 2022 UTC
.SUBCKT iiitb_vm
+ VGND VPWR clock out reset change.0 change.1 in.0 in.1
** replacing FILLER_0_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_0_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_0_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_113/VPB =>[signal: VPWR w=1]]']]
FILLER_0_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_125/VPB =>[signal: VPWR w=1]]']]
FILLER_0_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_141/VPB =>[signal: VPWR w=1]]']]
FILLER_0_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_0_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_0_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_0_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_29/VPB =>[signal: VPWR w=1]]']]
FILLER_0_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_41/VPB =>[signal: VPWR w=1]]']]
FILLER_0_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_57/VPB =>[signal: VPWR w=1]]']]
FILLER_0_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_69/VPB =>[signal: VPWR w=1]]']]
FILLER_0_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_85/VPB =>[signal: VPWR w=1]]']]
FILLER_0_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_9/VPB =>[signal: VPWR w=1]]']]
FILLER_0_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_97 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_109/VPB =>[signal: VPWR w=1]]']]
FILLER_10_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_121/VPB =>[signal: VPWR w=1]]']]
FILLER_10_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_139 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_10_141 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_10_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_15/VPB =>[signal: VPWR w=1]]']]
FILLER_10_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_159 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_159_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_159_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_10_163 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_10_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_29/VPB =>[signal: VPWR w=1]]']]
FILLER_10_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_3/VPB =>[signal: VPWR w=1]]']]
FILLER_10_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_41/VPB =>[signal: VPWR w=1]]']]
FILLER_10_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_53/VPB =>[signal: VPWR w=1]]']]
FILLER_10_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_65/VPB =>[signal: VPWR w=1]]']]
FILLER_10_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_85/VPB =>[signal: VPWR w=1]]']]
FILLER_10_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_97/VPB =>[signal: VPWR w=1]]']]
FILLER_10_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_11_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_113/VPB =>[signal: VPWR w=1]]']]
FILLER_11_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_125/VPB =>[signal: VPWR w=1]]']]
FILLER_11_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_137/VPB =>[signal: VPWR w=1]]']]
FILLER_11_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_149/VPB =>[signal: VPWR w=1]]']]
FILLER_11_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_15/VPB =>[signal: VPWR w=1]]']]
FILLER_11_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_11_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_27/VPB =>[signal: VPWR w=1]]']]
FILLER_11_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_3/VPB =>[signal: VPWR w=1]]']]
FILLER_11_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_39/VPB =>[signal: VPWR w=1]]']]
FILLER_11_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_11_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_57/VPB =>[signal: VPWR w=1]]']]
FILLER_11_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_69/VPB =>[signal: VPWR w=1]]']]
FILLER_11_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_81/VPB =>[signal: VPWR w=1]]']]
FILLER_11_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_93/VPB =>[signal: VPWR w=1]]']]
FILLER_11_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_109/VPB =>[signal: VPWR w=1]]']]
FILLER_12_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_121/VPB =>[signal: VPWR w=1]]']]
FILLER_12_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_141/VPB =>[signal: VPWR w=1]]']]
FILLER_12_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_15/VPB =>[signal: VPWR w=1]]']]
FILLER_12_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_12_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_12_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_29/VPB =>[signal: VPWR w=1]]']]
FILLER_12_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_3/VPB =>[signal: VPWR w=1]]']]
FILLER_12_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_41/VPB =>[signal: VPWR w=1]]']]
FILLER_12_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_53/VPB =>[signal: VPWR w=1]]']]
FILLER_12_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_65/VPB =>[signal: VPWR w=1]]']]
FILLER_12_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_85/VPB =>[signal: VPWR w=1]]']]
FILLER_12_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_97/VPB =>[signal: VPWR w=1]]']]
FILLER_12_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_13_11 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_13_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_113/VPB =>[signal: VPWR w=1]]']]
FILLER_13_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_125/VPB =>[signal: VPWR w=1]]']]
FILLER_13_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_137/VPB =>[signal: VPWR w=1]]']]
FILLER_13_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_149/VPB =>[signal: VPWR w=1]]']]
FILLER_13_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_16 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_16/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_16/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_16/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_16/VPB =>[signal: VPWR w=1]]']]
FILLER_13_16 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_13_28 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_28/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_28/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_28/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_28/VPB =>[signal: VPWR w=1]]']]
FILLER_13_28 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_3 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_13_40 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_40/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_40/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_40/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_40/VPB =>[signal: VPWR w=1]]']]
FILLER_13_40 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_52 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_13_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_57/VPB =>[signal: VPWR w=1]]']]
FILLER_13_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_69/VPB =>[signal: VPWR w=1]]']]
FILLER_13_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_81/VPB =>[signal: VPWR w=1]]']]
FILLER_13_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_93/VPB =>[signal: VPWR w=1]]']]
FILLER_13_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_108 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_108_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_108_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_14_116 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_14_134 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_134_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_134_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_14_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_141/VPB =>[signal: VPWR w=1]]']]
FILLER_14_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_15/VPB =>[signal: VPWR w=1]]']]
FILLER_14_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_14_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_14_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_14_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_29/VPB =>[signal: VPWR w=1]]']]
FILLER_14_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_3/VPB =>[signal: VPWR w=1]]']]
FILLER_14_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_41/VPB =>[signal: VPWR w=1]]']]
FILLER_14_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_53/VPB =>[signal: VPWR w=1]]']]
FILLER_14_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_65/VPB =>[signal: VPWR w=1]]']]
FILLER_14_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_14_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_14_85 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_14_91 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_15_10 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_10/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_10/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_10/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_10/VPB =>[signal: VPWR w=1]]']]
FILLER_15_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_15_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_15_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_113/VPB =>[signal: VPWR w=1]]']]
FILLER_15_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_125/VPB =>[signal: VPWR w=1]]']]
FILLER_15_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_137/VPB =>[signal: VPWR w=1]]']]
FILLER_15_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_149/VPB =>[signal: VPWR w=1]]']]
FILLER_15_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_15_22 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_22/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_22/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_22/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_22/VPB =>[signal: VPWR w=1]]']]
FILLER_15_22 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_15_34 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_34/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_34/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_34/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_34/VPB =>[signal: VPWR w=1]]']]
FILLER_15_34 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_46 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_54 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_15_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_57/VPB =>[signal: VPWR w=1]]']]
FILLER_15_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_69/VPB =>[signal: VPWR w=1]]']]
FILLER_15_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_81/VPB =>[signal: VPWR w=1]]']]
FILLER_15_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_93/VPB =>[signal: VPWR w=1]]']]
FILLER_15_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_110 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_110/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_110/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_110/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_110/VPB =>[signal: VPWR w=1]]']]
FILLER_16_110 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_122 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_122/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_122/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_122/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_122/VPB =>[signal: VPWR w=1]]']]
FILLER_16_122 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_134 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_134_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_134_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_16_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_141/VPB =>[signal: VPWR w=1]]']]
FILLER_16_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_16_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_16_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_16_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_16_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_29/VPB =>[signal: VPWR w=1]]']]
FILLER_16_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_16_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_41/VPB =>[signal: VPWR w=1]]']]
FILLER_16_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_53/VPB =>[signal: VPWR w=1]]']]
FILLER_16_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_65/VPB =>[signal: VPWR w=1]]']]
FILLER_16_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_16_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_16_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_85/VPB =>[signal: VPWR w=1]]']]
FILLER_16_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_9/VPB =>[signal: VPWR w=1]]']]
FILLER_16_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_17_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_17_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_113/VPB =>[signal: VPWR w=1]]']]
FILLER_17_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_125/VPB =>[signal: VPWR w=1]]']]
FILLER_17_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_137/VPB =>[signal: VPWR w=1]]']]
FILLER_17_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_149/VPB =>[signal: VPWR w=1]]']]
FILLER_17_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_15/VPB =>[signal: VPWR w=1]]']]
FILLER_17_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_17_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_27/VPB =>[signal: VPWR w=1]]']]
FILLER_17_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_3/VPB =>[signal: VPWR w=1]]']]
FILLER_17_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_39/VPB =>[signal: VPWR w=1]]']]
FILLER_17_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_17_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_57/VPB =>[signal: VPWR w=1]]']]
FILLER_17_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_69/VPB =>[signal: VPWR w=1]]']]
FILLER_17_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_81/VPB =>[signal: VPWR w=1]]']]
FILLER_17_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_93/VPB =>[signal: VPWR w=1]]']]
FILLER_17_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_100/VPB =>[signal: VPWR w=1]]']]
FILLER_18_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_112 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_112/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_112/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_112/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_112/VPB =>[signal: VPWR w=1]]']]
FILLER_18_112 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_124 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_124/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_124/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_124/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_124/VPB =>[signal: VPWR w=1]]']]
FILLER_18_124 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_136 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_136_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_136_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_18_141 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_18_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_15/VPB =>[signal: VPWR w=1]]']]
FILLER_18_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_150 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_150/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_150/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_150/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_150/VPB =>[signal: VPWR w=1]]']]
FILLER_18_150 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_162 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_18_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_18_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_29/VPB =>[signal: VPWR w=1]]']]
FILLER_18_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_3/VPB =>[signal: VPWR w=1]]']]
FILLER_18_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_41/VPB =>[signal: VPWR w=1]]']]
FILLER_18_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_53/VPB =>[signal: VPWR w=1]]']]
FILLER_18_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_65/VPB =>[signal: VPWR w=1]]']]
FILLER_18_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_18_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_18_85 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_18_93 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_19_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_19_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_19_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_113/VPB =>[signal: VPWR w=1]]']]
FILLER_19_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_125/VPB =>[signal: VPWR w=1]]']]
FILLER_19_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_137 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_145 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_19_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_15/VPB =>[signal: VPWR w=1]]']]
FILLER_19_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_154 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_154_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_154_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_162 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_19_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_27/VPB =>[signal: VPWR w=1]]']]
FILLER_19_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_3/VPB =>[signal: VPWR w=1]]']]
FILLER_19_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_39/VPB =>[signal: VPWR w=1]]']]
FILLER_19_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_19_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_57/VPB =>[signal: VPWR w=1]]']]
FILLER_19_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_69/VPB =>[signal: VPWR w=1]]']]
FILLER_19_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_81/VPB =>[signal: VPWR w=1]]']]
FILLER_19_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_93/VPB =>[signal: VPWR w=1]]']]
FILLER_19_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_1_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_113/VPB =>[signal: VPWR w=1]]']]
FILLER_1_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_125/VPB =>[signal: VPWR w=1]]']]
FILLER_1_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_137/VPB =>[signal: VPWR w=1]]']]
FILLER_1_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_149 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_149_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_149_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_1_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_15/VPB =>[signal: VPWR w=1]]']]
FILLER_1_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_157 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_162 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_1_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_27/VPB =>[signal: VPWR w=1]]']]
FILLER_1_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_3/VPB =>[signal: VPWR w=1]]']]
FILLER_1_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_39/VPB =>[signal: VPWR w=1]]']]
FILLER_1_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_57/VPB =>[signal: VPWR w=1]]']]
FILLER_1_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_69/VPB =>[signal: VPWR w=1]]']]
FILLER_1_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_81/VPB =>[signal: VPWR w=1]]']]
FILLER_1_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_93/VPB =>[signal: VPWR w=1]]']]
FILLER_1_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_109/VPB =>[signal: VPWR w=1]]']]
FILLER_20_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_121 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_121_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_121_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_20_129 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_20_134 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_134_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_134_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_20_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_141/VPB =>[signal: VPWR w=1]]']]
FILLER_20_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_15/VPB =>[signal: VPWR w=1]]']]
FILLER_20_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_20_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_20_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_20_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_29/VPB =>[signal: VPWR w=1]]']]
FILLER_20_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_3/VPB =>[signal: VPWR w=1]]']]
FILLER_20_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_41/VPB =>[signal: VPWR w=1]]']]
FILLER_20_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_53/VPB =>[signal: VPWR w=1]]']]
FILLER_20_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_65/VPB =>[signal: VPWR w=1]]']]
FILLER_20_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_20_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_20_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_85/VPB =>[signal: VPWR w=1]]']]
FILLER_20_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_97/VPB =>[signal: VPWR w=1]]']]
FILLER_20_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_21_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_21_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_113/VPB =>[signal: VPWR w=1]]']]
FILLER_21_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_125/VPB =>[signal: VPWR w=1]]']]
FILLER_21_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_137/VPB =>[signal: VPWR w=1]]']]
FILLER_21_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_149 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_149_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_149_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_21_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_15/VPB =>[signal: VPWR w=1]]']]
FILLER_21_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_157 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_21_162 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_21_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_27/VPB =>[signal: VPWR w=1]]']]
FILLER_21_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_3/VPB =>[signal: VPWR w=1]]']]
FILLER_21_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_39/VPB =>[signal: VPWR w=1]]']]
FILLER_21_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_21_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_21_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_57/VPB =>[signal: VPWR w=1]]']]
FILLER_21_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_69/VPB =>[signal: VPWR w=1]]']]
FILLER_21_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_81/VPB =>[signal: VPWR w=1]]']]
FILLER_21_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_93/VPB =>[signal: VPWR w=1]]']]
FILLER_21_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_109/VPB =>[signal: VPWR w=1]]']]
FILLER_22_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_121/VPB =>[signal: VPWR w=1]]']]
FILLER_22_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_22_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_141/VPB =>[signal: VPWR w=1]]']]
FILLER_22_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_15/VPB =>[signal: VPWR w=1]]']]
FILLER_22_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_22_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_22_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_22_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_29/VPB =>[signal: VPWR w=1]]']]
FILLER_22_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_3/VPB =>[signal: VPWR w=1]]']]
FILLER_22_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_41/VPB =>[signal: VPWR w=1]]']]
FILLER_22_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_53/VPB =>[signal: VPWR w=1]]']]
FILLER_22_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_65/VPB =>[signal: VPWR w=1]]']]
FILLER_22_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_22_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_85/VPB =>[signal: VPWR w=1]]']]
FILLER_22_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_97/VPB =>[signal: VPWR w=1]]']]
FILLER_22_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_23_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_23_113 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_121 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_129 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_129/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_129/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_129/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_129/VPB =>[signal: VPWR w=1]]']]
FILLER_23_129 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_141/VPB =>[signal: VPWR w=1]]']]
FILLER_23_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_15/VPB =>[signal: VPWR w=1]]']]
FILLER_23_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_23_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_27/VPB =>[signal: VPWR w=1]]']]
FILLER_23_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_3/VPB =>[signal: VPWR w=1]]']]
FILLER_23_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_39/VPB =>[signal: VPWR w=1]]']]
FILLER_23_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_23_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_57/VPB =>[signal: VPWR w=1]]']]
FILLER_23_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_69/VPB =>[signal: VPWR w=1]]']]
FILLER_23_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_81/VPB =>[signal: VPWR w=1]]']]
FILLER_23_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_93/VPB =>[signal: VPWR w=1]]']]
FILLER_23_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_111 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_111_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_111_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_24_119 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_24_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_24_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_141/VPB =>[signal: VPWR w=1]]']]
FILLER_24_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_15 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_24_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_24_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_24_24 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_24_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_29/VPB =>[signal: VPWR w=1]]']]
FILLER_24_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_3/VPB =>[signal: VPWR w=1]]']]
FILLER_24_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_41/VPB =>[signal: VPWR w=1]]']]
FILLER_24_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_53/VPB =>[signal: VPWR w=1]]']]
FILLER_24_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_24_75 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_24_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_24_85 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_24_91 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_24_99 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_99/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_99/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_99/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_99/VPB =>[signal: VPWR w=1]]']]
FILLER_24_99 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_25_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_25_113 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_25_120 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_120/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_120/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_120/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_120/VPB =>[signal: VPWR w=1]]']]
FILLER_25_120 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_132 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_132/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_132/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_132/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_132/VPB =>[signal: VPWR w=1]]']]
FILLER_25_132 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_144 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_144/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_144/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_144/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_144/VPB =>[signal: VPWR w=1]]']]
FILLER_25_144 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_15/VPB =>[signal: VPWR w=1]]']]
FILLER_25_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_156 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_156_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_156_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_25_27 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_25_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_3/VPB =>[signal: VPWR w=1]]']]
FILLER_25_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_31 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_25_35 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_35/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_35/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_35/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_35/VPB =>[signal: VPWR w=1]]']]
FILLER_25_35 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_47 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_25_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_25_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_57/VPB =>[signal: VPWR w=1]]']]
FILLER_25_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_69/VPB =>[signal: VPWR w=1]]']]
FILLER_25_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_81/VPB =>[signal: VPWR w=1]]']]
FILLER_25_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_93/VPB =>[signal: VPWR w=1]]']]
FILLER_25_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_109/VPB =>[signal: VPWR w=1]]']]
FILLER_26_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_121/VPB =>[signal: VPWR w=1]]']]
FILLER_26_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_26_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_141/VPB =>[signal: VPWR w=1]]']]
FILLER_26_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_15/VPB =>[signal: VPWR w=1]]']]
FILLER_26_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_26_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_26_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_26_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_29/VPB =>[signal: VPWR w=1]]']]
FILLER_26_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_3/VPB =>[signal: VPWR w=1]]']]
FILLER_26_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_41/VPB =>[signal: VPWR w=1]]']]
FILLER_26_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_53/VPB =>[signal: VPWR w=1]]']]
FILLER_26_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_65/VPB =>[signal: VPWR w=1]]']]
FILLER_26_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_26_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_85/VPB =>[signal: VPWR w=1]]']]
FILLER_26_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_97/VPB =>[signal: VPWR w=1]]']]
FILLER_26_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_109 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_27_113 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_27_121 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_27_126 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_126/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_126/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_126/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_126/VPB =>[signal: VPWR w=1]]']]
FILLER_27_126 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_138 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_27_14 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_14/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_14/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_14/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_14/VPB =>[signal: VPWR w=1]]']]
FILLER_27_14 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_141/VPB =>[signal: VPWR w=1]]']]
FILLER_27_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_27_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_27_26 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_27_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_29/VPB =>[signal: VPWR w=1]]']]
FILLER_27_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_3 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_27_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_41/VPB =>[signal: VPWR w=1]]']]
FILLER_27_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_27_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_57/VPB =>[signal: VPWR w=1]]']]
FILLER_27_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_69/VPB =>[signal: VPWR w=1]]']]
FILLER_27_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_27_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_85/VPB =>[signal: VPWR w=1]]']]
FILLER_27_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_9 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_27_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_97/VPB =>[signal: VPWR w=1]]']]
FILLER_27_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_109/VPB =>[signal: VPWR w=1]]']]
FILLER_2_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_121/VPB =>[signal: VPWR w=1]]']]
FILLER_2_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_141/VPB =>[signal: VPWR w=1]]']]
FILLER_2_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_15/VPB =>[signal: VPWR w=1]]']]
FILLER_2_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_2_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_2_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_29/VPB =>[signal: VPWR w=1]]']]
FILLER_2_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_3/VPB =>[signal: VPWR w=1]]']]
FILLER_2_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_41 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_2_49 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_2_55 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_55/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_55/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_55/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_55/VPB =>[signal: VPWR w=1]]']]
FILLER_2_55 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_67 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_67/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_67/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_67/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_67/VPB =>[signal: VPWR w=1]]']]
FILLER_2_67 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_79 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_85/VPB =>[signal: VPWR w=1]]']]
FILLER_2_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_97/VPB =>[signal: VPWR w=1]]']]
FILLER_2_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_103 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_103_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_103_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_3_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_3_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_113/VPB =>[signal: VPWR w=1]]']]
FILLER_3_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_125/VPB =>[signal: VPWR w=1]]']]
FILLER_3_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_137/VPB =>[signal: VPWR w=1]]']]
FILLER_3_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_149/VPB =>[signal: VPWR w=1]]']]
FILLER_3_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_15/VPB =>[signal: VPWR w=1]]']]
FILLER_3_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_3_27 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_3_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_3/VPB =>[signal: VPWR w=1]]']]
FILLER_3_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_35 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_3_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_57/VPB =>[signal: VPWR w=1]]']]
FILLER_3_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_69 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_3_75 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_3_79 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_79/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_79/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_79/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_79/VPB =>[signal: VPWR w=1]]']]
FILLER_3_79 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_91 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_91/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_91/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_91/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_91/VPB =>[signal: VPWR w=1]]']]
FILLER_3_91 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_109/VPB =>[signal: VPWR w=1]]']]
FILLER_4_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_121/VPB =>[signal: VPWR w=1]]']]
FILLER_4_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_4_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_4_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_141/VPB =>[signal: VPWR w=1]]']]
FILLER_4_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_15/VPB =>[signal: VPWR w=1]]']]
FILLER_4_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_4_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_4_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_3/VPB =>[signal: VPWR w=1]]']]
FILLER_4_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_51 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_51/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_51/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_51/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_51/VPB =>[signal: VPWR w=1]]']]
FILLER_4_51 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_63 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_63/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_63/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_63/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_63/VPB =>[signal: VPWR w=1]]']]
FILLER_4_63 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_75 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_4_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_85/VPB =>[signal: VPWR w=1]]']]
FILLER_4_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_97/VPB =>[signal: VPWR w=1]]']]
FILLER_4_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_100/VPB =>[signal: VPWR w=1]]']]
FILLER_5_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_113/VPB =>[signal: VPWR w=1]]']]
FILLER_5_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_125/VPB =>[signal: VPWR w=1]]']]
FILLER_5_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_137/VPB =>[signal: VPWR w=1]]']]
FILLER_5_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_149/VPB =>[signal: VPWR w=1]]']]
FILLER_5_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_15/VPB =>[signal: VPWR w=1]]']]
FILLER_5_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_5_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_27/VPB =>[signal: VPWR w=1]]']]
FILLER_5_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_3/VPB =>[signal: VPWR w=1]]']]
FILLER_5_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_39/VPB =>[signal: VPWR w=1]]']]
FILLER_5_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_57/VPB =>[signal: VPWR w=1]]']]
FILLER_5_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_69 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_5_76 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_76/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_76/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_76/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_76/VPB =>[signal: VPWR w=1]]']]
FILLER_5_76 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_88 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_88/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_88/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_88/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_88/VPB =>[signal: VPWR w=1]]']]
FILLER_5_88 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_101 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_107 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_107/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_107/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_107/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_107/VPB =>[signal: VPWR w=1]]']]
FILLER_6_107 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_119 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_119/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_119/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_119/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_119/VPB =>[signal: VPWR w=1]]']]
FILLER_6_119 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_131 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_131_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_131_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_6_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_141/VPB =>[signal: VPWR w=1]]']]
FILLER_6_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_15/VPB =>[signal: VPWR w=1]]']]
FILLER_6_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_6_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_6_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_29/VPB =>[signal: VPWR w=1]]']]
FILLER_6_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_3/VPB =>[signal: VPWR w=1]]']]
FILLER_6_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_41/VPB =>[signal: VPWR w=1]]']]
FILLER_6_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_53/VPB =>[signal: VPWR w=1]]']]
FILLER_6_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_65/VPB =>[signal: VPWR w=1]]']]
FILLER_6_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_6_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_6_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_85/VPB =>[signal: VPWR w=1]]']]
FILLER_6_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_97 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_7_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_7_118 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_118/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_118/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_118/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_118/VPB =>[signal: VPWR w=1]]']]
FILLER_7_118 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_130 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_130/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_130/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_130/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_130/VPB =>[signal: VPWR w=1]]']]
FILLER_7_130 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_142 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_142/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_142/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_142/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_142/VPB =>[signal: VPWR w=1]]']]
FILLER_7_142 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_15/VPB =>[signal: VPWR w=1]]']]
FILLER_7_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_154 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_154_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_154_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_7_162 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_7_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_27/VPB =>[signal: VPWR w=1]]']]
FILLER_7_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_3/VPB =>[signal: VPWR w=1]]']]
FILLER_7_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_39/VPB =>[signal: VPWR w=1]]']]
FILLER_7_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_57/VPB =>[signal: VPWR w=1]]']]
FILLER_7_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_69/VPB =>[signal: VPWR w=1]]']]
FILLER_7_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_81/VPB =>[signal: VPWR w=1]]']]
FILLER_7_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_93/VPB =>[signal: VPWR w=1]]']]
FILLER_7_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_103 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_103/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_103/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_103/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_103/VPB =>[signal: VPWR w=1]]']]
FILLER_8_103 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_115 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_122 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_122/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_122/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_122/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_122/VPB =>[signal: VPWR w=1]]']]
FILLER_8_122 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_134 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_134_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_134_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_8_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_141/VPB =>[signal: VPWR w=1]]']]
FILLER_8_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_15 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_8_153 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_153_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_153_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_8_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_8_20 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_8_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_29/VPB =>[signal: VPWR w=1]]']]
FILLER_8_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_3/VPB =>[signal: VPWR w=1]]']]
FILLER_8_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_41/VPB =>[signal: VPWR w=1]]']]
FILLER_8_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_53/VPB =>[signal: VPWR w=1]]']]
FILLER_8_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_65/VPB =>[signal: VPWR w=1]]']]
FILLER_8_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_8_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_85/VPB =>[signal: VPWR w=1]]']]
FILLER_8_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_97 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_106 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_106_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_106_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_9_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_113/VPB =>[signal: VPWR w=1]]']]
FILLER_9_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_125/VPB =>[signal: VPWR w=1]]']]
FILLER_9_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_137/VPB =>[signal: VPWR w=1]]']]
FILLER_9_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_149/VPB =>[signal: VPWR w=1]]']]
FILLER_9_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_15/VPB =>[signal: VPWR w=1]]']]
FILLER_9_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_161 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_9_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_27/VPB =>[signal: VPWR w=1]]']]
FILLER_9_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_3/VPB =>[signal: VPWR w=1]]']]
FILLER_9_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_39/VPB =>[signal: VPWR w=1]]']]
FILLER_9_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_9_75 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_9_82 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_82/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_82/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_82/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_82/VPB =>[signal: VPWR w=1]]']]
FILLER_9_82 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_94 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_94/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_94/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_94/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_94/VPB =>[signal: VPWR w=1]]']]
FILLER_9_94 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_28 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_28_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_28_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_29 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_30 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_31 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_31_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_31_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_32 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_32_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_32_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_33 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_34 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_35 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_36 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_37 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_38 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_38_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_38_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_39 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_39_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_39_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_40 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_40_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_40_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_41 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_42 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_42_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_42_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_43 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_43_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_43_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_44 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_44_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_44_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_45 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_46 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_47 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_48 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_49 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_50 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_50_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_50_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_51 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_52 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_54 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_54_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_54_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_55 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_55_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_55_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_100 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_101 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_102 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_103 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_104 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_105 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_106 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_107 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_108 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_109 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_110 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_111 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_112 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_113 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_114 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_115 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_116 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_117 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_118 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_119 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_120 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_121 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_122 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_123 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_124 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_125 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_126 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_127 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_128 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_129 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_130 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_56 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_57 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_58 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_59 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_60 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_61 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_62 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_63 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_64 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_65 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_66 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_67 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_68 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_69 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_70 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_71 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_72 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_73 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_74 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_75 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_76 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_77 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_78 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_79 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_80 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_81 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_82 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_83 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_84 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_85 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_86 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_87 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_88 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_89 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_90 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_91 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_92 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_93 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_94 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_95 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_96 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_97 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_98 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_99 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _20_ with the contents of sky130_fd_sc_hd__or4_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__20__0 _20__a_27_297# c_state[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__20__1 VGND c_state[2] _20__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_297# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__20__2 _07_ _20__a_27_297# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__20__3 VGND c_state[0] _20__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__20__4 VGND _20__a_27_297# _07_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_205_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__20__5 _20__a_109_297# c_state[3] _20__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_205_297# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_277_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__20__6 _20__a_205_297# c_state[0] _20__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_297# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__20__7 _20__a_27_297# c_state[3] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_277_297# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__20__8 _20__a_277_297# c_state[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__20__9 _07_ _20__a_27_297# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_297# w=1]]', 'g: [connection X10/g =>[signal: D w=1]]', 's: [connection X10/s =>[signal: a_109_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__20__10 _20__a_27_297# c_state[2] _20__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_27_297# w=1]]', 's: [connection X11/s =>[signal: X w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__20__11 VPWR _20__a_27_297# _07_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _21_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__21__0 _21__a_109_297# net2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__21__1 _08_ net2 VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__21__2 VGND net3 _08_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__21__3 _08_ net3 _21__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _22_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__22__0 _22__a_384_47# net3 VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__22__1 _09_ _22__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__22__2 _22__a_81_21# c_state[5] _22__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__22__3 VGND c_state[5] _22__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__22__4 _22__a_299_297# net2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__22__5 VPWR net3 _22__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__22__6 _09_ _22__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__22__7 _22__a_81_21# net2 _22__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _24_ with the contents of sky130_fd_sc_hd__a211o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_300_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__24__0 VGND _08_ _24__a_300_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__24__1 _04_ _24__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_80_21# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__24__2 _04_ _24__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_300_47# w=1]]', 'g: [connection X3/g =>[signal: A1 w=1]]', 's: [connection X3/s =>[signal: a_80_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__24__3 _24__a_300_47# _07_ _24__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_80_21# w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__24__4 _24__a_80_21# _09_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_472_297# w=1]]', 'g: [connection X5/g =>[signal: C1 w=1]]', 's: [connection X5/s =>[signal: a_80_21# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__24__5 _24__a_472_297# _10_ _24__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: C1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__24__6 VGND _10_ _24__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_217_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__24__7 VPWR _07_ _24__a_217_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_217_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__24__8 _24__a_217_297# _08_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_217_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_472_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__24__9 _24__a_217_297# _09_ _24__a_472_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _25_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__25__0 _25__a_150_297# c_state[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__25__1 VGND _25__a_68_297# _11_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__25__2 VGND c_state[3] _25__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__25__3 _25__a_68_297# c_state[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__25__4 _25__a_68_297# c_state[3] _25__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__25__5 VPWR _25__a_68_297# _11_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _26_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__26__0 VGND _11_ _26__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__26__1 net7 _26__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__26__2 net7 _26__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__26__3 VPWR _11_ _26__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _27_ with the contents of sky130_fd_sc_hd__and3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_209_311# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: a_296_53# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__27__0 _27__a_209_311# _27__a_109_93# _27__a_296_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_209_311# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__27__1 VGND _27__a_209_311# _12_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: a_109_93# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__27__2 VGND net2 _27__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_209_311# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__27__3 VPWR _27__a_209_311# _12_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: a_109_93# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__27__4 VPWR net2 _27__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_368_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__27__5 _27__a_368_53# net4 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_209_311# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__27__6 VPWR net3 _27__a_209_311# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_209_311# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__27__7 _27__a_209_311# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_296_53# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_368_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__27__8 _27__a_296_53# net3 _27__a_368_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_209_311# w=1]]', 'g: [connection X9/g =>[signal: a_109_93# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__27__9 _27__a_209_311# _27__a_109_93# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _28_ with the contents of sky130_fd_sc_hd__and3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_209_311# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: a_296_53# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__28__0 _28__a_209_311# _28__a_109_93# _28__a_296_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_209_311# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__28__1 VGND _28__a_209_311# _13_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: a_109_93# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__28__2 VGND net3 _28__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_209_311# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__28__3 VPWR _28__a_209_311# _13_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: a_109_93# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__28__4 VPWR net3 _28__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_368_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__28__5 _28__a_368_53# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_209_311# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__28__6 VPWR net4 _28__a_209_311# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_209_311# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__28__7 _28__a_209_311# net2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_296_53# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_368_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__28__8 _28__a_296_53# net4 _28__a_368_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_209_311# w=1]]', 'g: [connection X9/g =>[signal: a_109_93# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__28__9 _28__a_209_311# _28__a_109_93# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _29_ with the contents of sky130_fd_sc_hd__a22o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__29__0 _29__a_109_297# _12_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_109_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__29__1 VPWR _07_ _29__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_373_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__29__2 _29__a_373_47# _12_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_109_47# w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__29__3 _29__a_109_47# _13_ _29__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__29__4 VGND _29__a_27_297# _06_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_373_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__29__5 _29__a_27_297# _07_ _29__a_373_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_27_297# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__29__6 VPWR _29__a_27_297# _06_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B2 w=1]]', 's: [connection X7/s =>[signal: a_109_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__29__7 VGND c_state[4] _29__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: B2 w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__29__8 _29__a_27_297# c_state[4] _29__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_109_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_27_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__29__9 _29__a_109_297# _13_ _29__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _30_ with the contents of sky130_fd_sc_hd__a22o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__30__0 _30__a_109_297# _12_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_109_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__30__1 VPWR c_state[4] _30__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_373_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__30__2 _30__a_373_47# _12_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_109_47# w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__30__3 _30__a_109_47# _13_ _30__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__30__4 VGND _30__a_27_297# _05_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_373_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__30__5 _30__a_27_297# c_state[4] _30__a_373_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_27_297# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__30__6 VPWR _30__a_27_297# _05_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B2 w=1]]', 's: [connection X7/s =>[signal: a_109_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__30__7 VGND c_state[6] _30__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: B2 w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__30__8 _30__a_27_297# c_state[6] _30__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_109_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_27_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__30__9 _30__a_109_297# _13_ _30__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _31_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__31__0 _31__a_150_297# c_state[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__31__1 VGND _31__a_68_297# _14_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__31__2 VGND c_state[2] _31__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__31__3 _31__a_68_297# c_state[3] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__31__4 _31__a_68_297# c_state[2] _31__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__31__5 VPWR _31__a_68_297# _14_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _32_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__32__0 VGND _14_ _32__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__32__1 net5 _32__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__32__2 net5 _32__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__32__3 VPWR _14_ _32__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _33_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__33__0 VGND c_state[5] _33__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__33__1 _15_ _33__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__33__2 _15_ _33__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__33__3 VPWR c_state[5] _33__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _34_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__34__0 VGND _15_ _34__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__34__1 net6 _34__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__34__2 net6 _34__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__34__3 VPWR _15_ _34__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _35_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__35__0 _35__a_181_47# _08_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__35__1 _35__a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__35__2 VPWR c_state[6] _35__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__35__3 VPWR _35__a_27_47# _16_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__35__4 _35__a_109_47# c_state[6] _35__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__35__5 _35__a_27_47# net4 _35__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__35__6 VGND _35__a_27_47# _16_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__35__7 _35__a_27_47# _08_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _36_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__36__0 VGND _16_ _36__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__36__1 _03_ _36__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__36__2 _03_ _36__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__36__3 VPWR _16_ _36__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _37_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__37__0 VGND _37__a_59_75# _17_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__37__1 VPWR _07_ _37__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__37__2 _37__a_59_75# _07_ _37__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__37__3 _37__a_59_75# _13_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__37__4 _37__a_145_75# _13_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__37__5 VPWR _37__a_59_75# _17_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _38_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__38__0 VGND _17_ _38__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__38__1 _02_ _38__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__38__2 _02_ _38__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__38__3 VPWR _17_ _38__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _39_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__39__0 VGND _39__a_59_75# _18_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__39__1 VPWR c_state[6] _39__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__39__2 _39__a_59_75# c_state[6] _39__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__39__3 _39__a_59_75# _12_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__39__4 _39__a_145_75# _12_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__39__5 VPWR _39__a_59_75# _18_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _40_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__40__0 VGND _18_ _40__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__40__1 _01_ _40__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__40__2 _01_ _40__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__40__3 VPWR _18_ _40__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _41_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__41__0 _41__a_181_47# _08_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__41__1 _41__a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__41__2 VPWR c_state[4] _41__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__41__3 VPWR _41__a_27_47# _19_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__41__4 _41__a_109_47# c_state[4] _41__a_181_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__41__5 _41__a_27_47# net4 _41__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__41__6 VGND _41__a_27_47# _19_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__41__7 _41__a_27_47# _08_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _42_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__42__0 VGND _19_ _42__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__42__1 _00_ _42__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__42__2 _00_ _42__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__42__3 VPWR _19_ _42__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _43_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__43__0 _43__a_891_413# _43__a_193_47# _43__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__43__1 _43__a_1059_315# _43__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__43__2 _43__a_466_413# _43__a_27_47# _43__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__43__3 _43__a_634_159# _43__a_27_47# _43__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__43__4 _43__a_381_47# _43__a_193_47# _43__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__43__5 VPWR _04_ _43__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__43__6 VPWR _43__a_466_413# _43__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__43__7 VGND _43__a_466_413# _43__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__43__8 _43__a_1017_47# _43__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__43__9 _43__a_1059_315# _43__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__43__10 _43__a_561_413# _43__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__43__11 VPWR _43__a_1059_315# c_state[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__43__12 _43__a_891_413# _43__a_27_47# _43__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__43__13 _43__a_634_159# _43__a_193_47# _43__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__43__14 _43__a_592_47# _43__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__43__15 _43__a_466_413# _43__a_193_47# _43__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__43__16 VGND _43__a_27_47# _43__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__43__17 _43__a_381_47# _43__a_27_47# _43__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__43__18 _43__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__43__19 _43__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__43__20 VPWR _43__a_27_47# _43__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__43__21 VGND _04_ _43__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__43__22 _43__a_975_413# _43__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__43__23 VGND _43__a_1059_315# c_state[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _44_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__44__0 _44__a_891_413# _44__a_193_47# _44__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__44__1 _44__a_1059_315# _44__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__44__2 _44__a_466_413# _44__a_27_47# _44__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__44__3 _44__a_634_159# _44__a_27_47# _44__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__44__4 _44__a_381_47# _44__a_193_47# _44__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__44__5 VPWR _05_ _44__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__44__6 VPWR _44__a_466_413# _44__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__44__7 VGND _44__a_466_413# _44__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__44__8 _44__a_1017_47# _44__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__44__9 _44__a_1059_315# _44__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__44__10 _44__a_561_413# _44__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__44__11 VPWR _44__a_1059_315# c_state[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__44__12 _44__a_891_413# _44__a_27_47# _44__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__44__13 _44__a_634_159# _44__a_193_47# _44__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__44__14 _44__a_592_47# _44__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__44__15 _44__a_466_413# _44__a_193_47# _44__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__44__16 VGND _44__a_27_47# _44__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__44__17 _44__a_381_47# _44__a_27_47# _44__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__44__18 _44__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__44__19 _44__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__44__20 VPWR _44__a_27_47# _44__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__44__21 VGND _05_ _44__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__44__22 _44__a_975_413# _44__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__44__23 VGND _44__a_1059_315# c_state[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _45_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__45__0 _45__a_891_413# _45__a_193_47# _45__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__45__1 _45__a_1059_315# _45__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__45__2 _45__a_466_413# _45__a_27_47# _45__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__45__3 _45__a_634_159# _45__a_27_47# _45__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__45__4 _45__a_381_47# _45__a_193_47# _45__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__45__5 VPWR _00_ _45__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__45__6 VPWR _45__a_466_413# _45__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__45__7 VGND _45__a_466_413# _45__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__45__8 _45__a_1017_47# _45__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__45__9 _45__a_1059_315# _45__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__45__10 _45__a_561_413# _45__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__45__11 VPWR _45__a_1059_315# c_state[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__45__12 _45__a_891_413# _45__a_27_47# _45__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__45__13 _45__a_634_159# _45__a_193_47# _45__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__45__14 _45__a_592_47# _45__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__45__15 _45__a_466_413# _45__a_193_47# _45__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__45__16 VGND _45__a_27_47# _45__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__45__17 _45__a_381_47# _45__a_27_47# _45__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__45__18 _45__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__45__19 _45__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__45__20 VPWR _45__a_27_47# _45__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__45__21 VGND _00_ _45__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__45__22 _45__a_975_413# _45__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__45__23 VGND _45__a_1059_315# c_state[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _46_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__46__0 _46__a_891_413# _46__a_193_47# _46__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__46__1 _46__a_1059_315# _46__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__46__2 _46__a_466_413# _46__a_27_47# _46__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__46__3 _46__a_634_159# _46__a_27_47# _46__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__46__4 _46__a_381_47# _46__a_193_47# _46__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__46__5 VPWR _01_ _46__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__46__6 VPWR _46__a_466_413# _46__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__46__7 VGND _46__a_466_413# _46__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__46__8 _46__a_1017_47# _46__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__46__9 _46__a_1059_315# _46__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__46__10 _46__a_561_413# _46__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__46__11 VPWR _46__a_1059_315# c_state[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__46__12 _46__a_891_413# _46__a_27_47# _46__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__46__13 _46__a_634_159# _46__a_193_47# _46__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__46__14 _46__a_592_47# _46__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__46__15 _46__a_466_413# _46__a_193_47# _46__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__46__16 VGND _46__a_27_47# _46__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__46__17 _46__a_381_47# _46__a_27_47# _46__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__46__18 _46__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__46__19 _46__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__46__20 VPWR _46__a_27_47# _46__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__46__21 VGND _01_ _46__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__46__22 _46__a_975_413# _46__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__46__23 VGND _46__a_1059_315# c_state[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _47_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__47__0 _47__a_891_413# _47__a_193_47# _47__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__47__1 _47__a_1059_315# _47__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__47__2 _47__a_466_413# _47__a_27_47# _47__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__47__3 _47__a_634_159# _47__a_27_47# _47__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__47__4 _47__a_381_47# _47__a_193_47# _47__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__47__5 VPWR _02_ _47__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__47__6 VPWR _47__a_466_413# _47__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__47__7 VGND _47__a_466_413# _47__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__47__8 _47__a_1017_47# _47__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__47__9 _47__a_1059_315# _47__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__47__10 _47__a_561_413# _47__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__47__11 VPWR _47__a_1059_315# c_state[4] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__47__12 _47__a_891_413# _47__a_27_47# _47__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__47__13 _47__a_634_159# _47__a_193_47# _47__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__47__14 _47__a_592_47# _47__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__47__15 _47__a_466_413# _47__a_193_47# _47__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__47__16 VGND _47__a_27_47# _47__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__47__17 _47__a_381_47# _47__a_27_47# _47__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__47__18 _47__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__47__19 _47__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__47__20 VPWR _47__a_27_47# _47__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__47__21 VGND _02_ _47__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__47__22 _47__a_975_413# _47__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__47__23 VGND _47__a_1059_315# c_state[4] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _48_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__48__0 _48__a_891_413# _48__a_193_47# _48__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__48__1 _48__a_1059_315# _48__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__48__2 _48__a_466_413# _48__a_27_47# _48__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__48__3 _48__a_634_159# _48__a_27_47# _48__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__48__4 _48__a_381_47# _48__a_193_47# _48__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__48__5 VPWR _03_ _48__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__48__6 VPWR _48__a_466_413# _48__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__48__7 VGND _48__a_466_413# _48__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__48__8 _48__a_1017_47# _48__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__48__9 _48__a_1059_315# _48__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__48__10 _48__a_561_413# _48__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__48__11 VPWR _48__a_1059_315# c_state[5] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__48__12 _48__a_891_413# _48__a_27_47# _48__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__48__13 _48__a_634_159# _48__a_193_47# _48__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__48__14 _48__a_592_47# _48__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__48__15 _48__a_466_413# _48__a_193_47# _48__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__48__16 VGND _48__a_27_47# _48__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__48__17 _48__a_381_47# _48__a_27_47# _48__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__48__18 _48__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__48__19 _48__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__48__20 VPWR _48__a_27_47# _48__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__48__21 VGND _03_ _48__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__48__22 _48__a_975_413# _48__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__48__23 VGND _48__a_1059_315# c_state[5] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _49_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__49__0 _49__a_891_413# _49__a_193_47# _49__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__49__1 _49__a_1059_315# _49__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__49__2 _49__a_466_413# _49__a_27_47# _49__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__49__3 _49__a_634_159# _49__a_27_47# _49__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__49__4 _49__a_381_47# _49__a_193_47# _49__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__49__5 VPWR _06_ _49__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__49__6 VPWR _49__a_466_413# _49__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__49__7 VGND _49__a_466_413# _49__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__49__8 _49__a_1017_47# _49__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__49__9 _49__a_1059_315# _49__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__49__10 _49__a_561_413# _49__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__49__11 VPWR _49__a_1059_315# c_state[6] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__49__12 _49__a_891_413# _49__a_27_47# _49__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__49__13 _49__a_634_159# _49__a_193_47# _49__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__49__14 _49__a_592_47# _49__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__49__15 _49__a_466_413# _49__a_193_47# _49__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__49__16 VGND _49__a_27_47# _49__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__49__17 _49__a_381_47# _49__a_27_47# _49__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__49__18 _49__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__49__19 _49__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__49__20 VPWR _49__a_27_47# _49__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__49__21 VGND _06_ _49__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__49__22 _49__a_975_413# _49__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__49__23 VGND _49__a_1059_315# c_state[6] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 net1 input1_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input1_1 input1_a_27_47# clock VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 VGND input1_a_27_47# net1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 net1 input1_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_input1_4 VPWR input1_a_27_47# net1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input1_5 input1_a_27_47# clock VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_input2_0 input2_a_27_47# in.0 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_input2_1 input2_a_27_47# in.0 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X_input2_2 net2 input2_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR input2_a_27_47# net2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X_input2_4 net2 input2_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input2_5 VGND input2_a_27_47# net2 VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input3 with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_input3_0 input3_a_27_47# in.1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_input3_1 input3_a_27_47# in.1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X_input3_2 net3 input3_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input3_3 VPWR input3_a_27_47# net3 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X_input3_4 net3 input3_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input3_5 VGND input3_a_27_47# net3 VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input4 with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_input4_0 input4_a_27_47# reset VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_input4_1 input4_a_27_47# reset VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X_input4_2 net4 input4_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input4_3 VPWR input4_a_27_47# net4 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X_input4_4 net4 input4_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_input4_5 VGND input4_a_27_47# net4 VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output5 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output5_0 change.0 output5_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output5_1 output5_a_27_47# net5 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output5_2 VGND output5_a_27_47# change.0 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output5_3 change.0 output5_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output5_4 VPWR output5_a_27_47# change.0 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output5_5 output5_a_27_47# net5 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output6 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output6_0 change.1 output6_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output6_1 output6_a_27_47# net6 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output6_2 VGND output6_a_27_47# change.1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output6_3 change.1 output6_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output6_4 VPWR output6_a_27_47# change.1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output6_5 output6_a_27_47# net6 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output7 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output7_0 out output7_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output7_1 output7_a_27_47# net7 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output7_2 VGND output7_a_27_47# out VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output7_3 out output7_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output7_4 VPWR output7_a_27_47# out VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output7_5 output7_a_27_47# net7 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
